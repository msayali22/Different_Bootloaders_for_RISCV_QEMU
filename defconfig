## defconfig
```kconfig
CONFIG_ANY_TOOLCHAIN=y
CONFIG_BOARD_EMULATION_QEMU_RISCV_RV64=y
CONFIG_COREBOOT_ROMSIZE_KB_10240=y
CONFIG_RISCV_OPENSBI=y
```
